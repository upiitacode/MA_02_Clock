# Keil uVision project MA_02_Clock.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MA_02_Clock
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\include;..\retarget\include;..\STM32F30x_StdPeriph_Driver\inc;..\gcc\device\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group application
    ../source/: main.cc
  group other
    ../STM32F30x_StdPeriph_Driver/: SPL_STM32F302x8.lib
    ../source/: delay.c
  group serial
    ../retarget/source/: serial_stream.cc serial_stream_stm32f3.cc
  group timer
    ../source/: timer_15.cc timedclock.cc SerialShifter.c Clock.cc
  group segmentDisplayPanel
    ../source/: PanelShifterB.cc PanelSerializer.cc PanelDriver.cc PanelCharacterMap.cc
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Device:Startup 1.3.0
